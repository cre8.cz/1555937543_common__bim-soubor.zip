Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Número de proyecto
Time: 2016-05-04T13:14:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 04 13:14:49 2016 * Host: BICHO-B03 * Database: C:\Users\JORDIG~1\AppData\Local\Temp\{45959A04-0391-4DDE-BF87-A1A6EE0F47BA}\ifc * Database version: 5507 * Database creation date: Wed May 04 13:14:49 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 04 13:14:49 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 04 13:14:49 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Número de proyecto
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 25, 0, 86975; RefLongitude: -3, -42, -1, -243858; RefElevation: 0 m
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: Número de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: Número de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 m
Restricciones - Altura base: Punto base del proyecto; Alzado: 0 m
Otros - Categoría: Niveles; Nombre de familia: Nivel; Familia: Nivel: Nivel 1; Familia y tipo: Nivel: Nivel 1; ID de tipo: Nivel: Nivel 1; Tipo: Nivel: Nivel 1
Cotas - Altura de cálculo: 0 m
Datos de identidad - Estructura: no; Nombre: Nivel 1; Planta de edificio: yes; Nombre de tipo: Nivel 1
Gráficos - Color: 0; Grosor de línea: 1; Patrón de línea: Trazo punto; Símbolo: Extremo de nivel: Extremo de nivel; Símbolo en extremo 1 por defecto: no; Símbolo en extremo 2 por defecto: yes

# IfcFurnishingElement: COMMON (mesa 45), 2015_Table_Viccarbe_Common:COMMON (mesa 45):163395
In: Nivel 1
Type - ElementType: COMMON (mesa 45); Material: Lacquered MDF - Jet Black, Abedul
Type - Cotas - Height (inches): 18.50"; Height (mm): 0.45 m; Length (inches): 23.62"; Length (mm): 0.6 m; Width (inches): 23.62"; Width (mm): 0.6 m
Type - Datos de identidad - Bimetica: http://www.bimetica.com/; Collection: COMMON; Content Revision Date: 01/03/2016; Created by: Bimetica Parametric Design Services, S.L.; Descripción: Auxiliary tables inspired by the Japanese classics. Two different sizes make them very flexible and suitable for a variety of uses; Designer: NAOTO FUKUSAWA; Fabricante: VICCARBE; General Dimensions (inches): 18.50"x23.62"x23.62"; General Dimensions (mm): 45x60x60 cm; Information Expiry Date: 01/01/2017; Installation Date: -; Modelo: TABLE 45; Nombre de tipo: COMMON (mesa 45); Número OmniClass: 23.40.20.00; Product Contact Email: info@viccarbe.com; Product Contact Telephone: +34 96 120 10 10; Product Service Life: -; Product URL: http://www.viccarbe.com/product.php?id=1051aef4317b0e5; Reference Code: COD60H45; Series: TABLES; Technical information: http://www.viccarbe.com/archivos/viccarbe-common-table-en-info-12.pdf; Terms and Conditions of Sale: See the conditions on the pricelist.; Título OmniClass: General Furniture and Specialties; URL: http://www.viccarbe.com/; Warranty: 5 YEARS; Warranty URL: http://www.viccarbe.com/quality.php
Type - Materiales y acabados - Base Material: Abedul; Materials - Woods: http://www.viccarbe.com/archivos/VICCARBE_woods_maderas.pdf; Table Base Material: Lacquered MDF - Jet Black; Table Top Material: Lacquered MDF - Jet Black
Type - Otros - Categoría: Mobiliario; Nombre de familia: 2015_Table_Viccarbe_Common
Pset_ManufacturerTypeInformation - Manufacturer: VICCARBE
Cotas - Área: 0.494669 m2; Volumen: 0.00950031 m3
Otros - Familia: 2015_Table_Viccarbe_Common: COMMON (mesa 45); Familia y tipo: 2015_Table_Viccarbe_Common: COMMON (mesa 45); ID de tipo: 2015_Table_Viccarbe_Common: COMMON (mesa 45); Tipo: 2015_Table_Viccarbe_Common: COMMON (mesa 45)
Proceso por fases - Fase de creación: Nueva construcción
Restricciones - Anfitrión: Nivel : Nivel 1; Desfase: 0 m; Nivel: Nivel: Nivel 1; Se mueve con elementos cercanos: no
